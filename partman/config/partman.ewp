# IAR project partman.ewp, settings and files
configuration debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxF ST STM32F10xxF
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: partman0.hex
  ILINK.IlinkOutputFile: bootman.out
  ILINK.IlinkIcfFile: ..\config\stm32f10x_flash0.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration debug1 (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: partman1.hex
  ILINK.IlinkIcfFile: ..\config\stm32f10x_flash1.icf
  group (top)
    ../src/: partman.c
