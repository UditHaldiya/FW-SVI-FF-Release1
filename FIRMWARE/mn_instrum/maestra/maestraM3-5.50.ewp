# IAR project maestraM3-5.50.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: maestra.srec
  ILINK.IlinkOutputFile: maestra.out
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  group (top)
    ./: maestra.c maestra_instrum.c maestra_print.c
